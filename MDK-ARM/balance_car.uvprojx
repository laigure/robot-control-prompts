# Keil uVision project balance_car.uvprojx, settings and files
target balance_car (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x800FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: balance_car +hex
  c flags: Optim=4 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xB
  c misc: --cpp;--no_exceptions --no_rtti;--no-multibyte-chars
  c include: ../Core/Inc;../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;../Drivers/STM32F1xx_HAL_Driver/Inc;../Drivers/CMSIS/Device/ST/STM32F1xx/Include;../Drivers/CMSIS/Include;../Scr;../hardware;../src;../io;../tasks;../tools
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Application/MDK-ARM
    ./: startup_stm32f103xb.s
  group hardware
    ../hardware/: led.cpp led.h OLED.cpp OLED.h OLED_Data.cpp OLED_Data.h key.cpp key.h serial.cpp serial.h blue_serial.cpp blue_serial.h encoder.cpp encoder.h motor.cpp motor.h pwm.cpp pwm.h mpu6050.cpp mpu6050.h mpu6050_reg.h myi2c.cpp myi2c.h
  group Application/User/Core
    ../Core/Src/: main.cpp gpio.c tim.c usart.c stm32f1xx_it.c stm32f1xx_hal_msp.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32f1xx.c
  group oi
    ../io/: imu_mpu6050.hpp oled_panel.hpp uart_plot.hpp
  group src
    ../src/: balance_car_app.cpp balance_car_app.hpp
  group tasks
    ../tasks/: attitude_estimator.hpp
software components: CMSIS:CORE 4.3.0
